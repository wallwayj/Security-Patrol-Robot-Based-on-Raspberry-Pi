# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MALLOC +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\HARDWARE\KEY;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\HARDWARE\ESP8266;..\HARDWARE\USART3;..\HARDWARE\TIMER7;..\HARDWARE\PIO;..\HARDWARE\headfile;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\RC522;..\HARDWARE\RTC;..\USMART;..\SYSTEM\FLASH;..\HARDWARE\engine;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\MALLOC;..\FATFS\exfuns;..\FATFS\src\option;..\HARDWARE\SDIO;..\TEXT;..\HARDWARE\W25QXX;..\SIM800C;..\FATFS\src;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c touch.C ft5206.C gt9147.C ott2001a.C ctiic.C myiic.C
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER7/: timer.c
    ../HARDWARE/PIO/: pio.c
    ../HARDWARE/ADC/: AD.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/RC522/: RC522.c
    ../HARDWARE/engine/: PWM.c Servo.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../USMART/: usmart.c usmart_str.c usmart_config.c
    ../SYSTEM/FLASH/: Flash.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_spi.c
  group UCOSIII-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Instructions
    ../: readme.txt
  group SIM
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../MALLOC/: malloc.c
    ../SIM800C/: sim800c.c
    ../TEXT/: text.c fontupd.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: ff.c diskio.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
